## Kconfig
```kconfig
config RTL8852AU
	tristate "Realtek 8852A USB WiFi"
	depends on USB
	---help---
	  Help message of RTL8852AU
```
